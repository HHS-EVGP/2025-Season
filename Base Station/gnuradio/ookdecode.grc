options:
  parameters:
    generate_options: no_gui
    id: ookdecode
    output_language: python
    title: EVGP OOK Decoder
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.04'
    init: '0'
    low: '0.2'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Gap_Duration: '11'
    One_Duration: '13'
    Pause_Duration: '14'
    Send_Times: '1'
    Zero_Duration: '12'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Put documentation Here"""

          def __init__(self, Zero_Duration=12, One_Duration=13, Gap_Duration=11, Pause_Duration=14, Send_Times=1):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='OOK Decode',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.Zero_Duration = Zero_Duration
              self.One_Duration = One_Duration
              self.Gap_Duration = Gap_Duration
              self.Pause_Duration = Pause_Duration
              self.Send_Times = Send_Times

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]
              print(output_items)
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
